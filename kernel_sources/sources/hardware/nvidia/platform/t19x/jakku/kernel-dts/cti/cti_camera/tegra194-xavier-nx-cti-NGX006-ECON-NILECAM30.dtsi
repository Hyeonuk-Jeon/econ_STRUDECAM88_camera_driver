/*
 * Copyright (c) 2022, Connect Tech Inc.  All rights reserved.
 *
 * This program is free software; you can redistribute it and/or modify it
 * under the terms and conditions of the GNU General Public License,
 * version 2, as published by the Free Software Foundation.
 *
 * This program is distributed in the hope it will be useful, but WITHOUT
 * ANY WARRANTY; without even the implied warranty of MERCHANTABILITY or
 * FITNESS FOR A PARTICULAR PURPOSE.  See the GNU General Public License for
 * more details.
 *
 * You should have received a copy of the GNU General Public License
 * along with this program.  If not, see <http://www.gnu.org/licenses/>.
 */

#include "dt-bindings/clock/tegra194-clock.h"

//#define RST_IO_EXP TEGRA234_MAIN_GPIO(AC,1)
//#define PWM_CALIB_GPIO TEGRA234_MAIN_GPIO(H,7) //CAM0_PWDN
#define TRIGGER_SEL TEGRA194_MAIN_GPIO(R,0) //CAM0_RST
#define SERDES_PIX_CLK_HZ "375000000" //(1,500,000,000 x 4 lane / 16)
#define CAM_LANES 2
#define CAM_LANES_STRING "2" // was 2

#include "tegra194-xavier-nx-cti-camera-ECON-NILECAM30-modes.dtsi"


/ {

	gpio@2200000 {
		/*camera-control-output-high {
			status = "okay";
			gpio-hog;
			gpios = <RST_IO_EXP 0>;
			output-high;
			label = "rst-io-expender"; 
		};
		camera-control-output-low {
			status = "okay";
			gpio-hog;
			gpios = <TRIGGER_SEL 0>;
			output-low;
			label = "trigger_sel";
		};*/
	};

	i2c@31e0000 {
		clock-frequency = <100000>;
		tca9539_74: gpio@74 {
			compatible = "ti,tca9539";
			gpio-controller;
			#gpio-cells = <2>;
			reg = <0x74>;
			status = "okay";
			
			tca9539_74_outlow {
				status = "okay";
				gpio-hog;
				gpios = <0 0 1 0 2 0 3 0 4 0 5 0 6 0 7 0 8 0 9 0 10 0 11 0 12 0 13 0>;
				output-low;
				label = "RST_A","PWDN_A","RST_B","PWDN_B","RST_C","PWDN_C","RST_D","PWDN_D";
			};
			tca9539_74_outhigh {
				status = "disabled";
			};
			tca9539_74_input {
				status = "disabled";
			};
		};
	};

    i2c@3180000 {
	status = "okay";
	#address-cells = <1>;
	#size-cells = <0>;
        tca9544@70 {
	    status = "okay";
	    compatible = "nxp,pca9544";
	    reg = <0x70>;
	    #address-cells = <1>;
	    #size-cells = <0>;
	    vcc-supply = <&battery_reg>;
	    skip_mux_detect;
	    force_bus_start = <40>;
            i2c@0 {
                status = "okay";
		reg = <0>;
		i2c-mux,deselect-on-exit;
		#address-cells = <1>;
		#size-cells = <0>;
		ar0330_g@43 {
			status = "okay";
			compatible = "nvidia,ar0330";
			reg = <0x43>;
			sensor_model = "ar0330";
			avdd-reg = "vana";
			iovdd-reg = "vif";
			clocks = <&bpmp_clks TEGRA194_CLK_EXTPERIPH1>,<&bpmp_clks TEGRA194_CLK_PLLP_OUT0>;
			clock-names = "extperiph1","pllp_grtba";
			mclk = "extperiph1";
			clock-frequency = <24000000>;
			poc-gpio = <&tca9539_74 0 GPIO_ACTIVE_HIGH>;
			
			trigger-gpios = <&tegra_main_gpio TRIGGER_SEL GPIO_ACTIVE_LOW>;
			default-trigger = "internal";
			vana-supply = <&battery_reg>;
			vif-supply = <&battery_reg>;
			//vana-supply = <&vdd_cam_2v8>;
			//vif-supply = <&vdd_1v8_sys>;
			devnode = "video0";
			
			use_sensor_mode_id = "false";
			camera_mipi_lanes = <2>;
			camera-mipi-clk = <1200>;
			sio-port = "A";
			phy-id = "A";
			/*pwm-invert = <1>;
			pwm-duty_ns = <0x1CBC720>;
			pwm-period_ns = <0x2037FE7>;
			pwm-calib-gpio = <&tegra_main_gpio PWM_CALIB_GPIO GPIO_ACTIVE_HIGH>;
			pwm-name = "ecam-trigger";*/

#define LOCAL_VC_ID "0"
#define TEGRA_SINTERFACE "serial_c"
			mode0{
				NILECAM30_MODE0
			};
			
			ports {
				#address-cells = <1>;
				#size-cells = <0>;
				
				port@0 {
					reg = <0>;
					cam_out0: endpoint {
						status = "okay";
						vc-id = <0>;
						port-index = <2>;
						bus-width = <4>;
						remote-endpoint = <&csi_in0>;
					};
				};
			};	
		};     
		ar0330_h@44 {
			status = "okay";
			compatible = "nvidia,ar0330";
			reg = <0x44>;
			sensor_model = "ar0330";
			avdd-reg = "vana";
			iovdd-reg = "vif";
			clocks = <&bpmp_clks TEGRA194_CLK_EXTPERIPH1>,<&bpmp_clks TEGRA194_CLK_PLLP_OUT0>;
			clock-names = "extperiph1","pllp_grtba";
			mclk = "extperiph1";
			clock-frequency = <24000000>;
			//boot-gpios = <&tca9539_74 0 GPIO_ACTIVE_HIGH>;
			//pwdn-gpios = <&tca9539_74 1 GPIO_ACTIVE_HIGH>;
	
			trigger-gpios = <&tegra_main_gpio TRIGGER_SEL GPIO_ACTIVE_LOW>;
			default-trigger = "internal";
			vana-supply = <&battery_reg>;
			vif-supply = <&battery_reg>;
			devnode = "video1";
			
			use_sensor_mode_id = "false";
			camera_mipi_lanes = <2>;
			camera-mipi-clk = <1200>;
			sio-port = "B";
			phy-id = "B";
			/*pwm-invert = <1>;
			pwm-duty_ns = <0x1CBC720>;
			pwm-period_ns = <0x2037FE7>;
			pwm-calib-gpio = <&tegra_main_gpio PWM_CALIB_GPIO GPIO_ACTIVE_HIGH>;
			pwm-name = "ecam-trigger";*/
#undef TEGRA_SINTERFACE
#define TEGRA_SINTERFACE "serial_c"
#undef LOCAL_VC_ID
#define LOCAL_VC_ID "1"
			mode0 {
				NILECAM30_MODE0
			};
			
			ports {
				#address-cells = <1>;
				#size-cells = <0>;
				port@0 {
					reg = <0>;
					cam_out1: endpoint {
						vc-id = <1>;
						port-index = <2>;
						bus-width = <4>;
						remote-endpoint = <&csi_in1>;
					};
				};
			};	
		};           
            };

	    i2c@1 {
		status = "okay";
		reg = <1>;
		i2c-mux,deselect-on-exit;
		#address-cells = <1>;
		#size-cells = <0>;
		ar0330_e@43 {
			status = "okay";
			compatible = "nvidia,ar0330";
			reg = <0x43>;
			sensor_model = "ar0330";
			avdd-reg = "vana";
			iovdd-reg = "vif";
			clocks = <&bpmp_clks TEGRA194_CLK_EXTPERIPH1>,<&bpmp_clks TEGRA194_CLK_PLLP_OUT0>;
			clock-names = "extperiph1","pllp_grtba";
			mclk = "extperiph1";
			clock-frequency = <24000000>;
			//boot-gpios = <&tca9539_74 2 GPIO_ACTIVE_HIGH>;
			//pwdn-gpios = <&tca9539_74 3 GPIO_ACTIVE_HIGH>;
			poc-gpio = <&tca9539_74 7 GPIO_ACTIVE_HIGH>;
			trigger-gpios = <&tegra_main_gpio TRIGGER_SEL GPIO_ACTIVE_LOW>;
			default-trigger = "internal";
			vana-supply = <&battery_reg>;
			vif-supply = <&battery_reg>;
			devnode = "video4";
			use_sensor_mode_id = "false";
			camera_mipi_lanes = <2>;
			camera-mipi-clk = <1200>;
			sio-port = "A";
			phy-id = "A";
#undef LOCAL_VC_ID 
#define LOCAL_VC_ID "0"
#undef TEGRA_SINTERFACE
#define TEGRA_SINTERFACE "serial_a"
			mode0 {
				NILECAM30_MODE0
			};
			

			ports {
				#address-cells = <1>;
				#size-cells = <0>;
				port@0 {
					reg = <0>;
					cam_out2: endpoint {
						status = "okay";
						vc-id = <0>;
						port-index = <0>;
						bus-width = <4>;
						remote-endpoint = <&csi_in2>;
					};	
				};
			};
		};
		ar0330_f@44 {
			status = "okay";
			compatible = "nvidia,ar0330";
			reg = <0x44>;
			sensor_mode = "ar0330";
			avdd-reg = "vana";
			iovdd-reg = "vif";
			clocks = <&bpmp_clks TEGRA194_CLK_EXTPERIPH1>,<&bpmp_clks TEGRA194_CLK_PLLP_OUT0>;
			clock-names = "extperiph1","pllp_grtba";
			mclk = "extperiph1";
			clock-frequency = <24000000>;
			boot-gpios = <&tca9539_74 2 GPIO_ACTIVE_HIGH>;
			pwdn-gpios = <&tca9539_74 3 GPIO_ACTIVE_HIGH>;
			trigger-gpios = <&tegra_main_gpio TRIGGER_SEL GPIO_ACTIVE_LOW>;
			default-trigger = "internal";
			vana-supply = <&battery_reg>;
			vif-supply = <&battery_reg>;
			devnode = "video5";
			use_sensor_mode_id = "false";
			camera_mipi_lanes = <2>;
			camera-mipi-clk = <1200>;
			sio-port = "B";
			phy-id = "B";
#undef LOCAL_VC_ID 
#define LOCAL_VC_ID "1"
#undef TEGRA_SINTERFACE
#define TEGRA_SINTERFACE "serial_a"
			mode0 {
				NILECAM30_MODE0
			};
			
			ports {
				#address-cells = <1>;
				#size-cells = <0>;
				port@0 {
					reg = <0>;
					cam_out3: endpoint {
						status = "okay";
						vc-id = <1>;
						port-index = <0>;
						bus-width = <4>;
						remote-endpoint = <&csi_in3>;
					};
				};
			};
		};	 
	    };

         };
    };

    tegra-capture-vi {
        status = "okay";
        num-channels = <4>;
        ports {
	    #address-cells = <1>;
	    #size-cells = <0>;
	    status = "okay";
            port@0 {
		reg = <0>;
                status = "okay";
                vi_in0: endpoint {
		    vc-id = <0>;
                    port-index = <2>;
                    status = "okay";
                    bus-width = <4>;
		    remote-endpoint = <&csi_out0>;
                };
            };
            port@1 {
                status = "okay";
		reg = <1>;
                vi_in1: endpoint {
		    vc-id = <1>;
                    port-index = <2>;
                    status = "okay";
                    bus-width = <4>;
		    remote-endpoint = <&csi_out1>;
                };
            };
	    port@2 {
		status = "okay";
		reg = <2>;
		vi_in2: endpoint {
			vc-id = <0>;
			port-index = <0>;
			bus-width = <4>;
			remote-endpoint = <&csi_out2>;
			status = "okay";
		};
	    };
	    port@3{
		status = "okay";
		reg = <3>;
		vi_in3: endpoint {
			vc-id = <1>;
			port-index = <0>;
			bus-width = <4>;
			remote-endpoint = <&csi_out3>;
			status = "okay";
		};
	    };
        };
    };

    host1x@13e00000 {
        nvcsi@15a00000 {
	    num-channels = <4>;
	    #address-cells = <1>;
	    #size-cells = <0>;
            status = "okay";
            channel@0 {
                status = "okay";
		reg = <0>;
                ports {
		    #address-cells = <1>;
		    #size-cells = <0>;
                    port@0 {
                        status = "okay";
			reg = <0>;
                        csi_in0: endpoint@0 {
                            status = "okay";
                            port-index = <2>;
			    bus-width = <4>;
                            remote-endpoint = <&cam_out0>;
                        };
                    };
                    port@1 {
                        status = "okay";
			reg = <1>;
                        csi_out0: endpoint@1 {
                            status = "okay";
			    port-index = <2>;
			    bus-width = <4>;
			    remote-endpoint = <&vi_in0>;
                        };
                    };
                };
            };
            channel@1 {
                status = "okay";
		reg = <1>;
                ports {
		    #address-cells = <1>;
		    #size-cells = <0>;
                    
		    port@0 {
			reg = <0>;
                        status = "okay";
                        csi_in1: endpoint@2 {
                            status = "okay";
			    port-index = <2>;
                            bus-width = <4>;
                            remote-endpoint = <&cam_out1>;
                        };
                    };
                    port@1 {
                        status = "okay";
			reg = <1>;
                        csi_out1: endpoint@3 {
                            status = "okay";
			    port-index = <2>;
			    bus-width = <4>;
			    remote-endpoint = <&vi_in1>;
                        };
                    };
                };
            };
	    channel@2 {
                status = "okay";
		reg = <2>;
                ports {
		    #address-cells = <1>;
		    #size-cells = <0>;
                    port@0 {
                        status = "okay";
			reg = <0>;
                        csi_in2: endpoint@4 {
                            status = "okay";
                            port-index = <0>;
			    bus-width = <4>;
                            remote-endpoint = <&cam_out2>;
                        };
                    };
                    port@1 {
                        status = "okay";
			reg = <1>;
                        csi_out2: endpoint@5 {
                            status = "okay";
			    port-index = <0>;
			    bus-width = <4>;
			    remote-endpoint = <&vi_in2>;
                        };
                    };
                };
            };
            channel@3 {
                status = "okay";
		reg = <3>;
                ports {
		    #address-cells = <1>;
		    #size-cells = <0>;
                    
		    port@0 {
			reg = <0>;
                        status = "okay";
                        csi_in3: endpoint@6 {
                            status = "okay";
			    port-index = <0>;
                            bus-width = <4>;
                            remote-endpoint = <&cam_out3>;
                        };
                    };
                    port@1 {
                        status = "okay";
			reg = <1>;
                        csi_out3: endpoint@7 {
                            status = "okay";
			    port-index = <0>;
			    bus-width = <4>;
			    remote-endpoint = <&vi_in3>;
                        };
                    };
                };
            };
        };
    };


    tegra-camera-platform {
        num_csi_lanes = <8>;
        max_lane_speed = <1500000>;
        min_bits_per_pixel = <10>;
        vi_peak_byte_per_pixel = <2>;
        vi_bw_margin_pct = <25>;
	//max_pixel_rate = <750000>;
        isp_peak_byte_per_pixel = <5>;
        isp_bw_margin_pct = <25>;
	compatible = "nvidia, tegra-camera-platform";
	status = "okay";
        
	modules {
            module0 {
                status = "okay";
		badge = "ar0330";
		orientation = "1";
		position = "rear1"; 
                 drivernode0 {
                    status = "okay";
                    pcl_id = "v4l2_sensor";
                    devname = "ar0330 40-0043";
                    proc-device-tree = "/proc/device-tree/i2c@3180000/tca9544@70/i2c@0/ar0330_g@43";
                };
            };
	    module1 {
                status = "okay";
		badge = "ar0330";
		orientation = "2";
		position = "rear2";
                drivernode0 {
                    status = "okay";
                    pcl_id = "v4l2_sensor";
                    devname = "ar0330 40-0044";
                    proc-device-tree = "/proc/device-tree/i2c@3180000/tca9544@70/i2c@0/ar0330_h@44";
                };
            };
            
	    module2 {
		status = "okay";
		badge = "ar0330";
		orientation = "1";
		position = "rear3";
		drivernode0 {
			status = "okay";
			pcl_id = "v4l2_sensor";
			devname = "ar0330 41-0043";
			proc-device-tree = "/proc/device-tree/i2c@3180000/tca9544@70/i2c@1/ar0330_e@43";
		};
	    };
	    module3 {
		status = "okay";
		badge = "ar0330";
		orientation = "1";
		position = "rear4";
		drivernode0 {
			status = "okay";
			pcl_id = "v4l2_sensor";
			devname = "ar0330 41-0044";
			proc-device-tree = "/proc/device-tree/i2c@3180000/tca9544@70/i2c@1/ar0330_f@44";
		};
	    };
        };
    };
};

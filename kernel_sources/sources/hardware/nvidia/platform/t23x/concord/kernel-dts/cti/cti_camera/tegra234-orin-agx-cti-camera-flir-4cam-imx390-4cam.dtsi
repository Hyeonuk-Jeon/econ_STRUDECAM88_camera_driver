/*
 * Copyright (c) 2022, Connect Tech Inc.  All rights reserved.
 *
 * This program is free software; you can redistribute it and/or modify it
 * under the terms and conditions of the GNU General Public License,
 * version 2, as published by the Free Software Foundation.
 *
 * This program is distributed in the hope it will be useful, but WITHOUT
 * ANY WARRANTY; without even the implied warranty of MERCHANTABILITY or
 * FITNESS FOR A PARTICULAR PURPOSE.  See the GNU General Public License for
 * more details.
 *
 * You should have received a copy of the GNU General Public License
 * along with this program.  If not, see <http://www.gnu.org/licenses/>.
 */

#include "dt-bindings/clock/tegra234-clock.h"

#define RST_IO_EXP TEGRA234_MAIN_GPIO(AC,1)
#define PWM_CALIB_GPIO TEGRA234_MAIN_GPIO(H,7) //CAM0_PWDN
#define TRIGGER_SEL TEGRA234_MAIN_GPIO(I,0) //CAM0_RST
#define PWR_EN		TEGRA234_MAIN_GPIO(AC, 7)
#define CAM_LANES 4
#define SERDES_PIX_CLK_HZ "750000000"
#define CIL_SETTLETIME "0"

#define CTI_CAM_SENSOR_INFO \
        compatible = "cti,boson"; \
        physical_w = "7.7"; \
        physical_h = "6.1"; \
        sensor_model = "boson"; \
        use_decibel_gain = "false"; \
        use_sensor_mode_id = "true"; \


#define CTI_CAM_MODE_0 \
        /*mclk_khz = "25000";*/ \
        mclk_khz = "25000"; \
	num_lanes = "4"; \
        phy_mode = "DPHY";\
        discontinuous_clk = "no"; \
	dpcm_enable = "false"; \
        cil_settletime = CIL_SETTLETIME; \
	mode_type = "raw"; \
        pixel_phase = "y"; \
        dynamic_pixel_bit_depth = "8"; \
        csi_pixel_bit_depth = "8"; \
        active_w = "640"; \
        active_h = "512"; \
        readout_orientation = "0"; \
        line_length = "750"; \
        pix_clk_hz = "27000000"; \
        serdes_pix_clk_hz = SERDES_PIX_CLK_HZ; \
        inherent_gain = "1"; \
        gain_factor = "1"; \
        min_gain_val = "1"; \
        max_gain_val = "15"; \
        default_gain = "7"; \
        step_gain_val = "1"; \
        framerate_factor = "1000000"; \
        min_framerate = "60000000"; \
        max_framerate = "60000000"; \
        step_framerate = "1"; \
        default_framerate = "60000000"; \
        exposure_factor = "1000000"; \
        min_exp_time = "17"; \
        max_exp_time = "17"; \
        default_exp_time = "17"; \
        step_exp_time = "1"; \
        min_hdr_ratio = "1"; \
        max_hdr_ratio = "1"; \
        embedded_metadata_height = "0"; \
                                        
#define IMX390_MODE0 \
		mclk_khz = "24000"; \
		discontinuous_clk = "no"; \
		dpcm_enable = "false"; \
		cil_settletime = "0"; \
		dynamic_pixel_bit_depth = "12"; \
		csi_pixel_bit_depth = "12"; \
		mode_type = "bayer"; \
		pixel_phase = "rggb"; \
		active_w = "1920"; \
		active_h = "1080"; \
		readout_orientation = "0"; \
		line_length = "2200"; \
		inherent_gain = "1"; \
		pix_clk_hz = "74250000"; \
		serdes_pix_clk_hz = "480000000"; \
		gain_factor = "10"; \
		min_gain_val = "0";  \
		max_gain_val = "300"; \
		step_gain_val = "3"; \
		default_gain = "0"; \
		min_hdr_ratio = "1"; \
		max_hdr_ratio = "1"; \
		framerate_factor = "1000000"; \
		min_framerate = "30000000"; \
		max_framerate = "30000000"; \
		step_framerate = "1"; \
		default_framerate = "30000000"; \
		exposure_factor = "1000000"; \
		min_exp_time = "118"; \
		max_exp_time = "33333"; \
		step_exp_time = "1"; \
		default_exp_time = "33333"; \
		embedded_metadata_height = "0"; \


/ {

	gpio@2200000 {
		camera-control-output-high {
			status = "okay";
			gpio-hog;
			gpios = <RST_IO_EXP 0>;
			output-high;
			label = "rst-io-expender"; 
		};
		camera-control-output-low {
			status = "okay";
			gpio-hog;
			gpios = <TRIGGER_SEL 0>;
			output-low;
			label = "trigger_sel";
		};
	};

	

    i2c@31e0000 {
	status = "okay";
	#address-cells = <1>;
	#size-cells = <0>;
        tca9544@72 {
	    status = "okay";
	    compatible = "nxp,pca9544";
	    reg = <0x72>;
	    #address-cells = <1>;
	    #size-cells = <0>;
	    vcc-supply = <&vdd_1v8_sys>;
	    vcc-pullup-supply = <&battery_reg>;
	    vcc_lp = "vcc";
	    skip_mux_detect = "yes";
	    force_bus_start = <40>;
            i2c@0 {
                status = "okay";
		reg = <0>;
		i2c-mux,deselect-on-exit;
		#address-cells = <1>;
		#size-cells = <0>;

		dsera: li_max9296@48 {
			compatible = "li,li_max9296";
			reg = <0x48>;
			csi-mode = "2x4";
			max-src = <2>;
			status = "okay";
			reset-gpios = <&tca9539_74 0 GPIO_ACTIVE_HIGH>;
			//reset-gpios
		};
		ser_prima: li_max9295_prim@62 {
			compatible = "li,li_max9295";
			reg = <0x62>;
			is-prim-ser;
			status = "okay";
		};
		ser_a0: li_max9295_a@40 {
			compatible = "li,li_max9295";
			reg = <0x40>;
			nvidia,gmsl-dser-device = <&dsera>;
			status = "okay";
		};
		
		ser_b0: li_max9295_b@60 {
			compatible = "li,li_max9295";
			reg = <0x60>;
			nvidia,gmsl-dser-device = <&dsera>;
			status = "okay";
		};

		imx390_a@1b {
			def-addr = <0x21>;
			clocks = <&bpmp_clks TEGRA234_CLK_EXTPERIPH1>, <&bpmp_clks TEGRA234_CLK_EXTPERIPH1>;
			clock-names = "extperiph1", "pllp_grtba";
			mclk = "extperiph1";
			nvidia,gmsl-ser-device = <&ser_a0>;
			nvidia,gmsl-dser-device = <&dsera>;
			compatible = "li,imx390";
			reg = <0x1b>;
			reg_mux = <0>;

			physical_w = "15.0";
			physical_h = "12.5";
			sensor_model = "imx390";
			post_crop_frame_drop = "0";
			use_decibel_gain = "true";
			use_sensor_mode_id = "true";

			status = "okay";
			
			mode0 {
				IMX390_MODE0
				tegra_sinterface = "serial_g";
				num_lanes = "4";
				//mode_lanes = <4>;
				vc_id = "0";
			};

			ports {
				#address-cells = <1>;
				#size-cells = <0>;
				port@0{
					reg = <0>;
					cam_out0: endpoint {
						vc-id = <0>;
						port-index = <6>;
						bus-width = <CAM_LANES>;
						remote-endpoint = <&csi_in0>;

					};
				};
			};
			gmsl-link {
				src-csi-port = "b";
				dst-csi-port = "a";
				serdes-csi-link = "a";
				csi-mode = "1x4";
				st-vc = <0>;
				vc-id = <0>;
				num-lanes = <CAM_LANES>;
				streams = "ued-u1","raw12";

			};
		};

		imx390_b@1c {
			def-addr = <0x21>;
			clocks = <&bpmp_clks TEGRA234_CLK_EXTPERIPH1>, <&bpmp_clks TEGRA234_CLK_EXTPERIPH1>;
			clock-names = "extperiph1", "pllp_grtba";
			mclk = "extperiph1";
			compatible = "li,imx390";
			nvidia,gmsl-ser-device = <&ser_b0>;
			nvidia,gmsl-dser-device = <&dsera>;
			reg = <0x1c>;
			reg_mux = <0>;

			physical_w = "15.0";
			physical_h = "12.5";
			sensor_model = "imx390";
			post_crop_frame_drop = "0";
			use_decibel_gain = "true";
			use_sensor_mode_id = "true";

			status = "okay";
			mode0 {
				IMX390_MODE0
				tegra_sinterface = "serial_g";
				num_lanes = "4";
				//mode_lanes = <4>;
				vc_id = "1";
			};
			ports {
				#address-cells = <1>;
				#size-cells = <0>;
				port@0{
					reg = <0>;
					cam_out1: endpoint {
						vc-id = <0>;
						port-index = <6>;
						bus-width = <CAM_LANES>;
						remote-endpoint = <&csi_in1>;

					};
				};
			};
			gmsl-link {
				src-csi-port = "b";
				dst-csi-port = "a";
				serdes-csi-link = "b";
				csi-mode = "1x4";
				st-vc = <0>;
				vc-id = <1>;
				num-lanes = <CAM_LANES>;
				streams = "ued-u1","raw12";

			};
		};

		/*max9296_0: cti_max9296@48 {
			#address-cells = <1>;
			#size-cells = <0>;
			compatible = "cti,max929x";
			reg = <0x48>;
			status = "okay";
			cti,csi-freq-mhz = <1500>;
			cti,dt-overrides = <0x2a 0x2a 0x0 0x0>;
			cti,bpp-overrides = <0x8 0x8 0x0 0x0>;
			cti,vc-overrides = <0 1 2 3>;
			cti,lane-mode = <1>;
			//cti,auto-deskew;
			cti,always-on; 
			i2c@0 {
				#address-cells = <1>;
				#size-cells = <0>;
				reg = <0>;
				i2c-mux,deselect-on-exit;
				force_bus_start = <50>;
				
				cti_cam_g@1b {
					status = "okay";
					devnode = "video6";
					reg = <0x1b>;
					reset-gpios = <&tca9539_74 0 GPIO_ACTIVE_HIGH>;
					CTI_CAM_SENSOR_INFO
					
					mode0 {
						tegra_sinterface = "serial_g";
						vc_id = "0";
						CTI_CAM_MODE_0
					};

					ports {
						#address-cells = <1>;
						#size-cells = <0>;
						port@0{
							reg = <0>;
							cam_out0: endpoint {
								port-index = <6>;
								vc-id = <0>;
								bus-width = <4>;
								remote-endpoint = <&csi_in0>;
							};
						};
					};
				};
				cti_cam_h@1c {
					status = "okay";
					devnode = "video7";
					reg = <0x1c>;
					reset-gpios = <&tca9539_74 1 GPIO_ACTIVE_HIGH>;
					CTI_CAM_SENSOR_INFO
					
					mode0 {
						tegra_sinterface = "serial_g";
						vc_id = "1";
						CTI_CAM_MODE_0
					};

					ports {
						#address-cells = <1>;
						#size-cells = <0>;
						port@0{
							reg = <0>;
							cam_out1: endpoint {
								port-index = <6>;
								vc-id = <1>;
								bus-width = <4>;
								remote-endpoint = <&csi_in1>;
							};
						};
					};
				};
			};
			cti_max9295_A {
				reg = <0x42>;
				cti,def-addr = <0x42>;
				cti,lane-mode = <5>;
				cti,vc-id = <0>;
				cti,i2c-map = <0x1b 0x6c>;
				cti,pipes-dt = <0x2a 0 0 0>;

				ports {
					#address-cells = <1>;
					#size-cells = <0>;
					port@0 {
						reg = <0>;
						cti_max9295_a0_in: endpoint {
							//remote-endpoint = <&cam_out0>;
						};
					};
					port@1 {
						reg = <1>;
						cti_max9295_a0_out: endpoint {
							//remote-endpoint = <&csi_in0>;
						};
					};
				};
			};
			cti_max9295_B {
				reg = <0x40>;
				cti,def-addr = <0x42>;
				cti,lane-mode = <5>;
				cti,vc-id = <1>;
				cti,i2c-map = <0x1c 0x6c>;
				cti,pipes-dt = <0 0x2a 0 0>;
				ports {
					#address-cells = <1>;
					#size-cells = <0>;
					port@0 {
						reg = <0>;
						cti_max9295_b0_in: endpoint {
							//remote-endpoint = <&cam_out1>;
						};
					};
					port@1 {
						reg = <1>;
						cti_max9295_b0_out: endpoint {
							//remote-endpoint = <&csi_in1>;
						};
					};
				};
			};

		};*/
			
	     
            };

	    i2c@1 {
		status = "okay";
		reg = <1>;
		i2c-mux,deselect-on-exit;
		#address-cells = <1>;
		#size-cells = <0>;
		
		dserb: li_max9296@48 {
			compatible = "li,li_max9296";
			reg = <0x48>;
			csi-mode = "2x4";
			max-src = <2>;
			status = "okay";
			reset-gpios = <&tca9539_74 2 GPIO_ACTIVE_HIGH>;
		};
		ser_primb: li_max9295_prim@62 {
			compatible = "li,li_max9295";
			reg = <0x62>;
			is-prim-ser;
			status = "okay";
		};
		ser_a1: li_max9295_a@40 {
			compatible = "li,li_max9295";
			reg = <0x40>;
			nvidia,gmsl-dser-device = <&dserb>;
			status = "okay";
		};
		
		ser_b1: li_max9295_b@60 {
			compatible = "li,li_max9295";
			reg = <0x60>;
			nvidia,gmsl-dser-device = <&dserb>;
			status = "okay";
		};

		imx390_c@1b {
			def-addr = <0x21>;
			clocks = <&bpmp_clks TEGRA234_CLK_EXTPERIPH1>, <&bpmp_clks TEGRA234_CLK_EXTPERIPH1>;
			clock-names = "extperiph1", "pllp_grtba";
			mclk = "extperiph1";
			nvidia,gmsl-ser-device = <&ser_a1>;
			nvidia,gmsl-dser-device = <&dserb>;
			compatible = "li,imx390";
			reg = <0x1b>;
			reg_mux = <1>;

			physical_w = "15.0";
			physical_h = "12.5";
			sensor_model = "imx390";
			post_crop_frame_drop = "0";
			use_decibel_gain = "true";
			use_sensor_mode_id = "true";

			status = "okay";
			
			mode0 {
				IMX390_MODE0
				tegra_sinterface = "serial_e";
				num_lanes = "4";
				//mode_lanes = <4>;
				vc_id = "0";
			};

			ports {
				#address-cells = <1>;
				#size-cells = <0>;
				port@0{
					reg = <0>;
					cam_out2: endpoint {
						vc-id = <0>;
						port-index = <4>;
						bus-width = <CAM_LANES>;
						remote-endpoint = <&csi_in2>;

					};
				};
			};
			gmsl-link {
				src-csi-port = "b";
				dst-csi-port = "a";
				serdes-csi-link = "a";
				csi-mode = "1x4";
				st-vc = <0>;
				vc-id = <0>;
				num-lanes = <CAM_LANES>;
				streams = "ued-u1","raw12";

			};
		};

		imx390_d@1c {
			def-addr = <0x21>;
			clocks = <&bpmp_clks TEGRA234_CLK_EXTPERIPH1>, <&bpmp_clks TEGRA234_CLK_EXTPERIPH1>;
			clock-names = "extperiph1", "pllp_grtba";
			mclk = "extperiph1";
			compatible = "li,imx390";
			nvidia,gmsl-ser-device = <&ser_b1>;
			nvidia,gmsl-dser-device = <&dserb>;
			reg = <0x1c>;
			reg_mux = <1>;

			physical_w = "15.0";
			physical_h = "12.5";
			sensor_model = "imx390";
			post_crop_frame_drop = "0";
			use_decibel_gain = "true";
			use_sensor_mode_id = "true";

			status = "okay";
			mode0 {
				IMX390_MODE0
				tegra_sinterface = "serial_e";
				num_lanes = "4";
				//mode_lanes = <4>;
				vc_id = "1";
			};
			ports {
				#address-cells = <1>;
				#size-cells = <0>;
				port@0{
					reg = <0>;
					cam_out3: endpoint {
						vc-id = <0>;
						port-index = <4>;
						bus-width = <CAM_LANES>;
						remote-endpoint = <&csi_in3>;

					};
				};
			};
			gmsl-link {
				src-csi-port = "b";
				dst-csi-port = "a";
				serdes-csi-link = "b";
				csi-mode = "1x4";
				st-vc = <0>;
				vc-id = <1>;
				num-lanes = <CAM_LANES>;
				streams = "ued-u1","raw12";

			};
		};
		/*max9296_1: cti_max9296@48 {
			#address-cells = <1>;
			#size-cells = <0>;
			compatible = "cti,max929x";
			reg = <0x48>;
			status = "okay";
			cti,csi-freq-mhz = <1500>;
			cti,dt-overrides = <0x2a 0x2a 0x0 0x0>;
			cti,bpp-overrides = <0x8 0x8 0x0 0x0>;
			cti,vc-overrides = <0 1 2 3>;
			cti,lane-mode = <1>;
			//cti,auto-deskew;	
			cti,always-on; 
			i2c@0 {
				#address-cells = <1>;
				#size-cells = <0>;
				reg = <0>;
				i2c-mux,deselect-on-exit;
				force_bus_start = <51>;
				
				cti_cam_e@1b {
					status = "okay";
					devnode = "video4";
					reg = <0x1b>;
					reset-gpios = <&tca9539_74 2 GPIO_ACTIVE_HIGH>;
					CTI_CAM_SENSOR_INFO
					
					mode0 {
						tegra_sinterface = "serial_e";
						vc_id = "0";
						CTI_CAM_MODE_0
					};

					ports {
						#address-cells = <1>;
						#size-cells = <0>;
						port@0{
							reg = <0>;
							cam_out2: endpoint {
								port-index = <4>;
								vc-id = <0>;
								bus-width = <4>;
								remote-endpoint = <&csi_in2>;
							};
						};
					};
				};
				cti_cam_f@1c {
					status = "okay";
					devnode = "video5";
					reg = <0x1c>;
					reset-gpios = <&tca9539_74 3 GPIO_ACTIVE_HIGH>;
					CTI_CAM_SENSOR_INFO
					
					mode0 {
						tegra_sinterface = "serial_e";
						vc_id = "1";
						CTI_CAM_MODE_0
					};

					ports {
						#address-cells = <1>;
						#size-cells = <0>;
						port@0{
							reg = <0>;
							cam_out3: endpoint {
								port-index = <4>;
								vc-id = <1>;
								bus-width = <4>;
								remote-endpoint = <&csi_in3>;
							};
						};
					};
				};
			};
			cti_max9295_A {
				reg = <0x42>;
				cti,def-addr = <0x42>;
				cti,lane-mode = <5>;
				cti,vc-id = <0>;
				cti,i2c-map = <0x1b 0x6c>;
				cti,pipes-dt = <0x2a 0 0 0>;

				ports {
					#address-cells = <1>;
					#size-cells = <0>;
					port@0 {
						reg = <0>;
						cti_max9295_a1_in: endpoint {
							//remote-endpoint = <&cam_out0>;
						};
					};
					port@1 {
						reg = <1>;
						cti_max9295_a1_out: endpoint {
							//remote-endpoint = <&csi_in0>;
						};
					};
				};
			};
			cti_max9295_B {
				reg = <0x40>;
				cti,def-addr = <0x42>;
				cti,lane-mode = <5>;
				cti,vc-id = <1>;
				cti,i2c-map = <0x1c 0x6c>;
				cti,pipes-dt = <0 0x2a 0 0>;
				ports {
					#address-cells = <1>;
					#size-cells = <0>;
					port@0 {
						reg = <0>;
						cti_max9295_b1_in: endpoint {
							//remote-endpoint = <&cam_out1>;
						};
					};
					port@1 {
						reg = <1>;
						cti_max9295_b1_out: endpoint {
							//remote-endpoint = <&csi_in1>;
						};
					};
				};
			};

		};*/
		
	    };


            i2c@2 {
                status = "okay";
                reg = <2>;
		i2c-mux,deselect-on-exit;
		#address-cells = <1>;
		#size-cells = <0>;
		
		max9296_2: cti_max9296@48 {
			#address-cells = <1>;
			#size-cells = <0>;
			compatible = "cti,max929x";
			reg = <0x48>;
			status = "okay";
			cti,csi-freq-mhz = <1500>;
			cti,dt-overrides = <0x2a 0x2a 0x0 0x0>;
			cti,bpp-overrides = <0x8 0x8 0x0 0x0>;
			cti,vc-overrides = <0 1 2 3>;
			cti,lane-mode = <1>;
			//cti,auto-deskew;	
			cti,always-on; 
			i2c@0 {
				#address-cells = <1>;
				#size-cells = <0>;
				reg = <0>;
				i2c-mux,deselect-on-exit;
				force_bus_start = <52>;
				
				cti_cam_c@1b {
					status = "okay";
					devnode = "video2";
					reg = <0x1b>;
					reset-gpios = <&tca9539_74 4 GPIO_ACTIVE_HIGH>;
					CTI_CAM_SENSOR_INFO
					
					mode0 {
						tegra_sinterface = "serial_c";
						vc_id = "0";
						CTI_CAM_MODE_0
					};

					ports {
						#address-cells = <1>;
						#size-cells = <0>;
						port@0{
							reg = <0>;
							cam_out4: endpoint {
								port-index = <2>;
								vc-id = <0>;
								bus-width = <4>;
								remote-endpoint = <&csi_in4>;
							};
						};
					};
				};
				cti_cam_d@1c {
					status = "okay";
					devnode = "video3";
					reg = <0x1c>;
					reset-gpios = <&tca9539_74 5 GPIO_ACTIVE_HIGH>;
					CTI_CAM_SENSOR_INFO
					
					mode0 {
						tegra_sinterface = "serial_c";
						vc_id = "1";
						CTI_CAM_MODE_0
					};

					ports {
						#address-cells = <1>;
						#size-cells = <0>;
						port@0{
							reg = <0>;
							cam_out5: endpoint {
								port-index = <2>;
								vc-id = <1>;
								bus-width = <4>;
								remote-endpoint = <&csi_in5>;
							};
						};
					};
				};
			};
			cti_max9295_A {
				reg = <0x42>;
				cti,def-addr = <0x42>;
				cti,lane-mode = <5>;
				cti,vc-id = <0>;
				cti,i2c-map = <0x1b 0x6c>;
				cti,pipes-dt = <0x2a 0 0 0>;

				ports {
					#address-cells = <1>;
					#size-cells = <0>;
					port@0 {
						reg = <0>;
						cti_max9295_a2_in: endpoint {
							//remote-endpoint = <&cam_out0>;
						};
					};
					port@1 {
						reg = <1>;
						cti_max9295_a2_out: endpoint {
							//remote-endpoint = <&csi_in0>;
						};
					};
				};
			};
			cti_max9295_B {
				reg = <0x40>;
				cti,def-addr = <0x42>;
				cti,lane-mode = <5>;
				cti,vc-id = <1>;
				cti,i2c-map = <0x1c 0x6c>;
				cti,pipes-dt = <0 0x2a 0 0>;
				ports {
					#address-cells = <1>;
					#size-cells = <0>;
					port@0 {
						reg = <0>;
						cti_max9295_b2_in: endpoint {
							//remote-endpoint = <&cam_out1>;
						};
					};
					port@1 {
						reg = <1>;
						cti_max9295_b2_out: endpoint {
							//remote-endpoint = <&csi_in1>;
						};
					};
				};
			};

		};
		
		
            };
                
            i2c@3 {
                status = "okay";
		reg = <3>;
		i2c-mux,deselect-on-exit;
		#address-cells = <1>;
		#size-cells = <0>;
		max9296_3: cti_max9296@48 {
			#address-cells = <1>;
			#size-cells = <0>;
			compatible = "cti,max929x";
			reg = <0x48>;
			status = "okay";
			cti,csi-freq-mhz = <1500>;
			cti,dt-overrides = <0x2a 0x2a 0x0 0x0>;
			cti,bpp-overrides = <0x8 0x8 0x0 0x0>;
			cti,vc-overrides = <0 1 2 3>;
			cti,lane-mode = <1>;
			//cti,auto-deskew;	
			cti,always-on; 
			i2c@0 {
				#address-cells = <1>;
				#size-cells = <0>;
				reg = <0>;
				i2c-mux,deselect-on-exit;
				force_bus_start = <53>;
				
				cti_cam_a@1b {
					status = "okay";
					devnode = "video0";
					reg = <0x1b>;
					reset-gpios = <&tca9539_74 6 GPIO_ACTIVE_HIGH>;
					CTI_CAM_SENSOR_INFO
					
					mode0 {
						tegra_sinterface = "serial_a";
						vc_id = "0";
						CTI_CAM_MODE_0
					};

					ports {
						#address-cells = <1>;
						#size-cells = <0>;
						port@0{
							reg = <0>;
							cam_out6: endpoint {
								port-index = <0>;
								vc-id = <0>;
								bus-width = <4>;
								remote-endpoint = <&csi_in6>;
							};
						};
					};
				};
				cti_cam_b@1c {
					status = "okay";
					devnode = "video1";
					reg = <0x1c>;
					reset-gpios = <&tca9539_74 7 GPIO_ACTIVE_HIGH>;
					CTI_CAM_SENSOR_INFO
					
					mode0 {
						tegra_sinterface = "serial_a";
						vc_id = "1";
						CTI_CAM_MODE_0
					};

					ports {
						#address-cells = <1>;
						#size-cells = <0>;
						port@0{
							reg = <0>;
							cam_out7: endpoint {
								port-index = <0>;
								vc-id = <1>;
								bus-width = <4>;
								remote-endpoint = <&csi_in7>;
							};
						};
					};
				};
			};
			cti_max9295_A {
				reg = <0x42>;
				cti,def-addr = <0x42>;
				cti,lane-mode = <5>;
				cti,vc-id = <0>;
				cti,i2c-map = <0x1b 0x6c>;
				cti,pipes-dt = <0x2a 0 0 0>;

				ports {
					#address-cells = <1>;
					#size-cells = <0>;
					port@0 {
						reg = <0>;
						cti_max9295_a3_in: endpoint {
							//remote-endpoint = <&cam_out0>;
						};
					};
					port@1 {
						reg = <1>;
						cti_max9295_a3_out: endpoint {
							//remote-endpoint = <&csi_in0>;
						};
					};
				};
			};
			cti_max9295_B {
				reg = <0x40>;
				cti,def-addr = <0x42>;
				cti,lane-mode = <5>;
				cti,vc-id = <1>;
				cti,i2c-map = <0x1c 0x6c>;
				cti,pipes-dt = <0 0x2a 0 0>;
				ports {
					#address-cells = <1>;
					#size-cells = <0>;
					port@0 {
						reg = <0>;
						cti_max9295_b3_in: endpoint {
							//remote-endpoint = <&cam_out1>;
						};
					};
					port@1 {
						reg = <1>;
						cti_max9295_b3_out: endpoint {
							//remote-endpoint = <&csi_in1>;
						};
					};
				};
			};

		};			
		
            };
        };
    };

    i2c@3180000 {
		status = "okay";
		#address-cells = <1>;
		#size-cells = <0>;
		tca9539_74: tca9539@74 {
			compatible = "ti,tca9539";
			gpio-controller;
			#gpio-cells = <2>;
			ngpios = <16>;
			reg = <0x74>;
			vcc-supply = <&battery_reg>;
			status = "okay";
			
			tca9539_74_outlow {
				status = "okay";
				gpio-hog;
				gpios = <0 0 1 0 2 0 3 0 4 0 5 0 6 0 7 0 8 0 9 0 10 0 11 0 12 0 13 0>;
				output-low;
				label = "RST_A","PWDN_A","RST_B","PWDN_B","RST_C","PWDN_C","RST_D","PWDN_D";
			};
			tca9539_74_outhigh {
				status = "disabled";
			};
			tca9539_74_input {
				status = "disabled";
			};
		};
	};
    tegra-capture-vi {
        status = "okay";
        num-channels = <8>;
        ports {
	    #address-cells = <1>;
	    #size-cells = <0>;
	    status = "okay";
            port@0 {
		reg = <0>;
                status = "okay";
                vi_in0: endpoint {
		    vc-id = <0>;
                    port-index = <5>;
                    status = "okay";
                    bus-width = <CAM_LANES>;
		    remote-endpoint = <&csi_out0>;
                };
            };
            port@1 {
                status = "okay";
		reg = <1>;
                vi_in1: endpoint {
		    vc-id = <1>;
                    port-index = <5>;
                    status = "okay";
                    bus-width = <CAM_LANES>;
		    remote-endpoint = <&csi_out1>;
                };
            };
	    port@2 {
		status = "okay";
		reg = <2>;
		vi_in2: endpoint {
			vc-id = <0>;
			port-index = <4>;
			bus-width = <CAM_LANES>;
			remote-endpoint = <&csi_out2>;
			status = "okay";
		};
	    };
	    port@3{
		status = "okay";
		reg = <3>;
		vi_in3: endpoint {
			vc-id = <1>;
			port-index = <4>;
			bus-width = <CAM_LANES>;
			remote-endpoint = <&csi_out3>;
			status = "okay";
		};
	    };
	    port@4 {
		status = "okay";
		reg = <4>;
		vi_in4: endpoint {
			vc-id = <0>;
			port-index = <2>;
			bus-width = <CAM_LANES>;
			remote-endpoint = <&csi_out4>;
			status = "okay";
		};
	    };
	    port@5 {
		status = "okay";
		reg = <5>;
		vi_in5: endpoint {
			vc-id = <1>;
			port-index = <2>;
			bus-width = <CAM_LANES>;
			remote-endpoint = <&csi_out5>;
			status = "okay";
		};
	    };
            port@6 {
                status = "okay";
		reg = <6>;
                vi_in6: endpoint {
                    port-index = <0>;
                    status = "okay";
                    bus-width = <CAM_LANES>;
		    vc-id = <0>;
		    remote-endpoint = <&csi_out6>;
                };
            };
            port@7 {
                status = "okay";
		reg = <7>;
                vi_in7: endpoint {
                    port-index = <0>;
                    status = "okay";
                    bus-width = <CAM_LANES>;
		    vc-id = <1>;
		    remote-endpoint = <&csi_out7>;
                };
            };
        };
    };

    host1x@13e00000 {
        nvcsi@15a00000 {
	    num-channels = <8>;
	    #address-cells = <1>;
	    #size-cells = <0>;
            status = "okay";
            channel@0 {
                status = "okay";
		reg = <0>;
                ports {
		    #address-cells = <1>;
		    #size-cells = <0>;
                    port@0 {
                        status = "okay";
			reg = <0>;
                        csi_in0: endpoint@0 {
                            status = "okay";
                            port-index = <6>;
			    vc-id = <0>;
			    bus-width = <CAM_LANES>;
                            remote-endpoint = <&cam_out0>;
                        };
                    };
                    port@1 {
                        status = "okay";
			reg = <1>;
                        csi_out0: endpoint@1 {
                            status = "okay";
			    port-index = <6>;
			    vc-id = <0>;
			    bus-width = <CAM_LANES>;
			    remote-endpoint = <&vi_in0>;
                        };
                    };
                };
            };
            channel@1 {
                status = "okay";
		reg = <1>;
                ports {
		    #address-cells = <1>;
		    #size-cells = <0>;
                    
		    port@0 {
			reg = <0>;
                        status = "okay";
                        csi_in1: endpoint@2 {
                            status = "okay";
			    port-index = <6>;
			    vc-id = <1>;
                            bus-width = <CAM_LANES>;
                            remote-endpoint = <&cam_out1>;
                        };
                    };
                    port@1 {
                        status = "okay";
			reg = <1>;
                        csi_out1: endpoint@3 {
                            status = "okay";
			    port-index = <6>;
			    vc-id = <1>;
			    bus-width = <CAM_LANES>;
			    remote-endpoint = <&vi_in1>;
                        };
                    };
                };
            };
	    channel@2 {
                status = "okay";
		reg = <2>;
                ports {
		    #address-cells = <1>;
		    #size-cells = <0>;
                    port@0 {
                        status = "okay";
			reg = <0>;
                        csi_in2: endpoint@4 {
                            status = "okay";
                            port-index = <4>;
			    bus-width = <CAM_LANES>;
                            remote-endpoint = <&cam_out2>;
                        };
                    };
                    port@1 {
                        status = "okay";
			reg = <1>;
                        csi_out2: endpoint@5 {
                            status = "okay";
			    port-index = <4>;
			    bus-width = <CAM_LANES>;
			    remote-endpoint = <&vi_in2>;
                        };
                    };
                };
            };
            channel@3 {
                status = "okay";
		reg = <3>;
                ports {
		    #address-cells = <1>;
		    #size-cells = <0>;
                    
		    port@0 {
			reg = <0>;
                        status = "okay";
                        csi_in3: endpoint@6 {
                            status = "okay";
			    port-index = <4>;
                            bus-width = <CAM_LANES>;
                            remote-endpoint = <&cam_out3>;
                        };
                    };
                    port@1 {
                        status = "okay";
			reg = <1>;
                        csi_out3: endpoint@7 {
                            status = "okay";
			    port-index = <4>;
			    bus-width = <CAM_LANES>;
			    remote-endpoint = <&vi_in3>;
                        };
                    };
                };
            };
	    channel@4 {
                status = "okay";
		reg = <4>;
                ports {
		    #address-cells = <1>;
		    #size-cells = <0>;
                    port@0 {
                        status = "okay";
			reg = <0>;
                        csi_in4: endpoint@8 {
                            status = "okay";
                            port-index = <2>;
			    bus-width = <CAM_LANES>;
                            remote-endpoint = <&cam_out4>;
                        };
                    };
                    port@1 {
                        status = "okay";
			reg = <1>;
                        csi_out4: endpoint@9 {
                            status = "okay";
			    port-index = <2>;
			    bus-width = <CAM_LANES>;
			    remote-endpoint = <&vi_in4>;
                        };
                    };
                };
            };
            channel@5 {
                status = "okay";
		reg = <5>;
                ports {
		    #address-cells = <1>;
		    #size-cells = <0>;
                    
		    port@0 {
			reg = <0>;
                        status = "okay";
                        csi_in5: endpoint@10 {
                            status = "okay";
			    port-index = <2>;
                            bus-width = <CAM_LANES>;
                            remote-endpoint = <&cam_out5>;
                        };
                    };
                    port@1 {
                        status = "okay";
			reg = <1>;
                        csi_out5: endpoint@11 {
                            status = "okay";
			    port-index = <2>;
			    bus-width = <CAM_LANES>;
			    remote-endpoint = <&vi_in5>;
                        };
                    };
                };
            };

            channel@6 {
                status = "okay";
		reg = <6>;
                ports {
		    #address-cells = <1>;
		    #size-cells = <0>;
                    port@0 {
			reg = <0>;
                        status = "okay";
                        csi_in6: endpoint@12 {
                            status = "okay";
                            bus-width = <CAM_LANES>;
			    port-index = <0>;
			    remote-endpoint = <&cam_out6>;
                        };
                    };
                    port@1 {
                        status = "okay";
                        reg = <1>;
			csi_out6: endpoint@13 {
                            status = "okay";
			    remote-endpoint = <&vi_in6>;
                        };
                    };
                };
            };

            channel@7 {
                status = "okay";
		reg = <7>;
                ports {
		    #address-cells = <1>;
		    #size-cells = <0>;
                    port@0 {
			reg = <0>;
                        status = "okay";
                        csi_in7: endpoint@14 {
                            status = "okay";
                            bus-width = <CAM_LANES>;
			    port-index = <0>;
			    remote-endpoint = <&cam_out7>;
                        };
                    };
                    port@1 {
                        status = "okay";
			reg = <1>;
                        csi_out7: endpoint@15 {
                            status = "okay";
			    remote-endpoint = <&vi_in7>;
                        };
                    };
                };
            };
        };
    };


    tegra-camera-platform {
        num_csi_lanes = <16>;
        max_lane_speed = <4000000>;
        min_bits_per_pixel = <8>;
        vi_peak_byte_per_pixel = <1>;
        vi_bw_margin_pct = <25>;
	max_pixel_rate = <240000>;
        isp_peak_byte_per_pixel = <5>;
        isp_bw_margin_pct = <25>;
	compatible = "nvidia, tegra-camera-platform";
	status = "okay";
        
	modules {
		status = "okay";
		module0 {
			status = "okay";
			badge = "cti_front_cam";
			position = "front";
			orientation = "1";
			drivernode0 {
				status = "okay";
				pcl_id = "v4l2_sensor";
				devname = "imx390 40-001b";
				proc-device-tree = "/proc/device-tree/i2c@31e0000/tca9544@72/i2c@0/imx390_a@1b";
			};
			
		};
		module1 {
			status = "okay";
			badge = "cti_rear_cam";
			position = "cti_rear_cam";
			orientation = "1";
			drivernode0 {
				status = "okay";
				pcl_id = "v4l2_sensor";
				devname = "imx390 40-001c";
				proc-device-tree = "/proc/device-tree/i2c@31e0000/tca9544@72/i2c@0/imx390_b@1c";
			};
		};
		module2 {
			status = "okay";
			badge = "cti_bottomleft_cam";
			position = "bottomleft";
			orientation = "1";
			drivernode0 {
				status = "okay";
				pcl_id = "v4l2_sensor";
				devname = "imx390 41-001b";
				proc-device-tree = "/proc/device-tree/i2c@31e0000/tca9544@72/i2c@1/imx390_c@1b";
			};
		};
		module3 {
			status = "okay";
			badge = "cti_bottomright_cam";
			position = "bottomright";
			orientation = "1";
			drivernode0 {
				status = "okay";
				pcl_id = "v4l2_sensor";
				devname = "imx390 41-001c";
				proc-device-tree = "/proc/device-tree/i2c@31e0000/tca9544@72/i2c@1/imx390_d@1c";
			};
		};
		module4 {
			status = "okay";
			badge = "cti_centerleft";
			position = "centerleft";
			orientation = "1";
			drivernode0 {
				status = "okay";
				pcl_id = "v4l2_sensor";
				devname = "cti_boson 42-001b";
				proc-device-tree = "/proc/device-tree/i2c@31e0000/tca9544@72/i2c@2/cti_cam_c@1b";
			};
		};
		module5 {
			status = "okay";
			badge = "cti_centerright";
			position = "centerright";
			orientation = "1";
			drivernode0 {
				status = "okay";
				pcl_id = "v4l2_sensor";
				devname = "cti_boson 42-001c";
				proc-device-tree = "/proc/device-tree/i2c@31e0000/tca9544@72/i2c@2/cti_cam_d@1c";
			};
		};
		module6 {
			status = "okay";
			badge = "cti_backleft";
			position = "backleft";
			orientation = "1";
			drivernode0 {
				status = "okay";
				pcl_id = "v4l2_sensor";
				devname = "cti_boson 43-001b";
				proc-device-tree = "/proc/device-tree/i2c@31e0000/tca9544@72/i2c@3/cti_cam_a@1b";
			};
		};
		module7 {
			status = "okay";
			badge = "cti_backright";
			position = "backright";
			orientation = "1";
			drivernode0 {
				status = "okay";
				pcl_id = "v4l2_sensor";
				devname = "cti_boson 43-001c";
				proc-device-tree = "/proc/device-tree/i2c@31e0000/tca9544@72/i2c@3/cti_cam_b@1c";
			};
		};
		
        };
    };
};

/*
 * Copyright (c) 2022, Connect Tech Inc.  All rights reserved.
 *
 * This program is free software; you can redistribute it and/or modify it
 * under the terms and conditions of the GNU General Public License,
 * version 2, as published by the Free Software Foundation.
 *
 * This program is distributed in the hope it will be useful, but WITHOUT
 * ANY WARRANTY; without even the implied warranty of MERCHANTABILITY or
 * FITNESS FOR A PARTICULAR PURPOSE.  See the GNU General Public License for
 * more details.
 *
 * You should have received a copy of the GNU General Public License
 * along with this program.  If not, see <http://www.gnu.org/licenses/>.
 */

#include "dt-bindings/clock/tegra234-clock.h"

#define CAMERA_I2C_MUX_BUS(x) (0x1E + x)
#define RST_IO_EXP TEGRA234_MAIN_GPIO(AC,1)
#define PWM_CALIB_GPIO TEGRA234_MAIN_GPIO(H,7) //CAM0_PWDN
#define TRIGGER_SEL TEGRA234_MAIN_GPIO(I,0) //CAM0_RST
#define PWR_EN      TEGRA234_MAIN_GPIO(AC, 7)

//default
#define PIX_CLK_HZ        "750000000"
//#define PIX_CLK_HZ        "900000000"
//#define PIX_CLK_HZ        "248000000"
//#define SERDES_PIX_CLK_HZ "250000000"
#define PIX_BIT_DEPTH "4" //OG value

#define AVT_MODE_0 \
    discontinuous_clk = "no";  \
    cil_settletime = "0"; \
    embedded_metadata_height = "0"; \
    mclk_khz = "24000"; \
    phy_mode = "DPHY"; \
    dpcm_enable = "false"; \
    csi_pixel_bit_depth = PIX_BIT_DEPTH; \
    active_w = "5488"; \
    active_h = "4112"; \
    pixel_t = "bayer_bggr"; \
    readout_orientation = "0"; \
    line_length = "5488"; \
    inherent_gain = "1"; \
    mclk_multiplier = "31.25"; \
    pix_clk_hz = PIX_CLK_HZ; \
    gain_factor = "16"; \
    framerate_factor = "1000000"; \
    exposure_factor = "1000000"; \
    min_gain_val = "16"; \
    max_gain_val = "256"; \
    step_gain_val = "1"; \
    min_hdr_ratio = "1"; \
    max_hdr_ratio = "64"; \
    min_framerate = "1500000"; \
    max_framerate = "30000000"; \
    step_framerate = "1"; \
    min_exp_time = "34"; \
    max_exp_time = "550385"; \
    step_exp_time = "1";



#define AVT_NODE_COMMON \
    status = "okay"; \
    clocks = <&bpmp_clks TEGRA234_CLK_EXTPERIPH1>, \
             <&bpmp_clks TEGRA234_CLK_PLLP_OUT0>; \
    clock-names = "extperiph1", "pllp_grtba"; \
    mclk = "extperiph1"; \
    compatible = "alliedvision,avt_csi2";

#define SERDES_STATE "okay"                                       


/ {

	gpio@2200000 {
		camera-control-output-high {
			status = "okay";
			gpio-hog;
			gpios = <RST_IO_EXP 0>;
			output-high;
			label = "rst-io-expender"; 
		};
		camera-control-output-low {
			status = "okay";
			gpio-hog;
			gpios = <TRIGGER_SEL 0>;
			output-low;
			label = "trigger_sel";
		};
	};

	

    i2c@31e0000 {
	status = "okay";
	#address-cells = <1>;
	#size-cells = <0>;
        tca9544@72 {
	    status = "okay";
	    compatible = "nxp,pca9544";
	    reg = <0x72>;
	    #address-cells = <1>;
	    #size-cells = <0>;
	    vcc-supply = <&vdd_1v8_sys>;
	    vcc-pullup-supply = <&battery_reg>;
	    vcc_lp = "vcc";
	    skip_mux_detect = "yes";
	    force_bus_start = <40>;
            i2c@0 {
                status = "okay";
		reg = <0>;
		i2c-mux,deselect-on-exit;
		#address-cells = <1>;
		#size-cells = <0>;

		max9296_0: cti_max9296@48 {
			#address-cells = <1>;
			#size-cells = <0>;
			compatible = "cti,max929x";
			reg = <0x48>;
			status = SERDES_STATE;
			cti,csi-freq-mhz = <1500>;
			cti,lane-mode = <1>;
			cti,always-on; 
			i2c@0 {
				#address-cells = <1>;
				#size-cells = <0>;
				reg = <0>;
				i2c-mux,deselect-on-exit;
				force_bus_start = <50>;
			        avt_csi2_a@32 {
				    AVT_NODE_COMMON
				    devnode = "video0";
				    reg = <0x32>;
				    csi_clk_freq = <650000000>;
				    csi_lanes = "4";

				    mode0 {
					num_lanes = "4";
					vc_id = "0";
					tegra_sinterface = "serial_g";
					AVT_MODE_0
				    };

				    ports{
					#address-cells = <1>;
					#size-cells = <0>;
					port@0 {
					    reg = <0>;
					    avt_csi2_cam_out0: endpoint {
						port-index = <6>;
						bus-width = <4>;
						vc-id = <0>;
						remote-endpoint = <&avt_csi2_csi_in0>;
					    };
					};
				    };
				};
				avt_csi2_b@33 {
					AVT_NODE_COMMON
					devnode = "video1";
					reg = <0x33>;
					csi_clk_freq = <650000000>;
					csi_lanes = "4";
					mode0 {
					    num_lanes = "4";
					    vc_id = "1";
					    tegra_sinterface = "serial_g";
					    AVT_MODE_0
					};

					ports{
					    #address-cells = <1>;
					    #size-cells = <0>;
					    port@0 {
						reg = <0>;
						avt_csi2_cam_out1: endpoint {
						    port-index = <6>;
						    bus-width = <4>;
						    vc-id = <1>;
						    remote-endpoint = <&avt_csi2_csi_in1>;
						};
					    };
					};
				 };   
                    
			};
			cti_max96717_A {
				reg = <0x40>;
				cti,def-addr = <0x40>;
				cti,lane-mode = <1>; //was 5
				cti,vc-id = <0>;
				cti,i2c-map = <0x32 0x3c>;
				cti,tx-pipe = <2>;
				cti,pipes-dt = <0x0 0x0 0x24 0x0>;

				ports {
					#address-cells = <1>;
					#size-cells = <0>;
					port@0 {
						reg = <0>;
						cti_max9295_a0_in: endpoint {
							//remote-endpoint = <&cam_out0>;
						};
					};
					port@1 {
						reg = <1>;
						cti_max9295_a0_out: endpoint {
							//remote-endpoint = <&avt_csi2_csi_in0>;
						};
					};
				};
			};
			cti_max96717_B {
				reg = <0x62>; //force to 62
				cti,def-addr = <0x40>;
				cti,lane-mode = <1>;
				cti,vc-id = <1>;
				cti,i2c-map = <0x33 0x3c>;
				cti,pipes-dt = <0x24 0 0 0>;
				cti,tx-pipe = <0>;
				ports {
				    #address-cells = <1>;
				    #size-cells = <0>;
				    port@0 {
					reg = <0>;
					cti_max9295_b0_in: endpoint {
					    //remote-endpoint = <&cam_out1>;
					};
				    };
				    port@1 {
					reg = <1>;
					cti_max9295_b0_out: endpoint {
					    //remote-endpoint = <&avt_csi2_csi_in1>;
					};
				    };
				};
			    };


		};
			

        };
	i2c@1 {
                status = "okay";
		reg = <1>;
		i2c-mux,deselect-on-exit;
		#address-cells = <1>;
		#size-cells = <0>;

		max9296_1: cti_max9296@48 {
			#address-cells = <1>;
			#size-cells = <0>;
			compatible = "cti,max929x";
			reg = <0x48>;
			status = SERDES_STATE;
			cti,csi-freq-mhz = <1500>;
			cti,lane-mode = <1>;
			cti,always-on; 
			i2c@0 {
				#address-cells = <1>;
				#size-cells = <0>;
				reg = <0>;
				i2c-mux,deselect-on-exit;
				force_bus_start = <51>;
			        avt_csi2_c@32 {
				    AVT_NODE_COMMON
				    devnode = "video1";
				    reg = <0x32>;
				    csi_clk_freq = <650000000>;
				    csi_lanes = "4";

				    mode0 {
					num_lanes = "4";
					vc_id = "0";
					tegra_sinterface = "serial_e";
					AVT_MODE_0
				    };

				    ports{
					#address-cells = <1>;
					#size-cells = <0>;
					port@0 {
					    reg = <0>;
					    avt_csi2_cam_out2: endpoint {
						port-index = <4>;
						bus-width = <4>;
						vc-id = <0>;
						remote-endpoint = <&avt_csi2_csi_in2>;
					    };
					};
				    };
				};
				avt_csi2_d@33 {
					AVT_NODE_COMMON
					devnode = "video3";
					reg = <0x33>;
					csi_clk_freq = <650000000>;
					csi_lanes = "4";
					mode0 {
					    num_lanes = "4";
					    vc_id = "1";
					    tegra_sinterface = "serial_e";
					    AVT_MODE_0
					};

					ports{
					    #address-cells = <1>;
					    #size-cells = <0>;
					    port@0 {
						reg = <0>;
						avt_csi2_cam_out3: endpoint {
						    port-index = <4>;
						    bus-width = <4>;
						    vc-id = <1>;
						    remote-endpoint = <&avt_csi2_csi_in3>;
						};
					    };
					};
				 };   
                    
			};
			cti_max96717_A {
				reg = <0x40>;
				cti,def-addr = <0x40>;
				cti,lane-mode = <1>; //was 5
				cti,vc-id = <0>;
				cti,i2c-map = <0x32 0x3c>;
				cti,tx-pipe = <2>;
				cti,pipes-dt = <0x0 0x0 0x24 0x0>;

				ports {
					#address-cells = <1>;
					#size-cells = <0>;
					port@0 {
						reg = <0>;
						cti_max9295_a1_in: endpoint {
							//remote-endpoint = <&cam_out0>;
						};
					};
					port@1 {
						reg = <1>;
						cti_max9295_a1_out: endpoint {
							//remote-endpoint = <&avt_csi2_csi_in0>;
						};
					};
				};
			};
			cti_max96717_B {
				reg = <0x62>; //force to 62
				cti,def-addr = <0x40>;
				cti,lane-mode = <1>;
				cti,vc-id = <1>;
				cti,i2c-map = <0x33 0x3c>;
				cti,pipes-dt = <0x24 0 0 0>;
				cti,tx-pipe = <0>;
				ports {
				    #address-cells = <1>;
				    #size-cells = <0>;
				    port@0 {
					reg = <0>;
					cti_max9295_b1_in: endpoint {
					    //remote-endpoint = <&cam_out1>;
					};
				    };
				    port@1 {
					reg = <1>;
					cti_max9295_b1_out: endpoint {
					    //remote-endpoint = <&avt_csi2_csi_in1>;
					};
				    };
				};
			    };


		};
			
            };
	    i2c@2 {
                status = "okay";
		reg = <2>;
		i2c-mux,deselect-on-exit;
		#address-cells = <1>;
		#size-cells = <0>;

		max9296_2: cti_max9296@48 {
			#address-cells = <1>;
			#size-cells = <0>;
			compatible = "cti,max929x";
			reg = <0x48>;
			status = SERDES_STATE;
			cti,csi-freq-mhz = <1500>;
			cti,lane-mode = <1>;
			cti,always-on; 
			i2c@0 {
				#address-cells = <1>;
				#size-cells = <0>;
				reg = <0>;
				i2c-mux,deselect-on-exit;
				force_bus_start = <52>;
			        avt_csi2_e@32 {
				    AVT_NODE_COMMON
				    devnode = "video4";
				    reg = <0x32>;
				    csi_clk_freq = <650000000>;
				    csi_lanes = "4";

				    mode0 {
					num_lanes = "4";
					vc_id = "0";
					tegra_sinterface = "serial_c";
					AVT_MODE_0
				    };

				    ports{
					#address-cells = <1>;
					#size-cells = <0>;
					port@0 {
					    reg = <0>;
					    avt_csi2_cam_out4: endpoint {
						port-index = <2>;
						bus-width = <4>;
						vc-id = <0>;
						remote-endpoint = <&avt_csi2_csi_in4>;
					    };
					};
				    };
				};
				avt_csi2_f@33 {
					AVT_NODE_COMMON
					devnode = "video5";
					reg = <0x33>;
					csi_clk_freq = <650000000>;
					csi_lanes = "4";
					mode0 {
					    num_lanes = "4";
					    vc_id = "1";
					    tegra_sinterface = "serial_c";
					    AVT_MODE_0
					};

					ports{
					    #address-cells = <1>;
					    #size-cells = <0>;
					    port@0 {
						reg = <0>;
						avt_csi2_cam_out5: endpoint {
						    port-index = <2>;
						    bus-width = <4>;
						    vc-id = <1>;
						    remote-endpoint = <&avt_csi2_csi_in5>;
						};
					    };
					};
				 };   
                    
			};
			cti_max96717_A {
				reg = <0x40>;
				cti,def-addr = <0x40>;
				cti,lane-mode = <1>; //was 5
				cti,vc-id = <0>;
				cti,i2c-map = <0x32 0x3c>;
				cti,tx-pipe = <2>;
				cti,pipes-dt = <0x0 0x0 0x24 0x0>;

				ports {
					#address-cells = <1>;
					#size-cells = <0>;
					port@0 {
						reg = <0>;
						cti_max9295_a2_in: endpoint {
							//remote-endpoint = <&cam_out0>;
						};
					};
					port@1 {
						reg = <1>;
						cti_max9295_a2_out: endpoint {
							//remote-endpoint = <&avt_csi2_csi_in0>;
						};
					};
				};
			};
			cti_max96717_B {
				reg = <0x62>; //force to 62
				cti,def-addr = <0x40>;
				cti,lane-mode = <1>;
				cti,vc-id = <1>;
				cti,i2c-map = <0x33 0x3c>;
				cti,pipes-dt = <0x24 0 0 0>;
				cti,tx-pipe = <0>;
				ports {
				    #address-cells = <1>;
				    #size-cells = <0>;
				    port@0 {
					reg = <0>;
					cti_max9295_b2_in: endpoint {
					    //remote-endpoint = <&cam_out1>;
					};
				    };
				    port@1 {
					reg = <1>;
					cti_max9295_b2_out: endpoint {
					    //remote-endpoint = <&avt_csi2_csi_in1>;
					};
				    };
				};
			    };


		};
			
            };
	    i2c@3 {
                status = "okay";
		reg = <3>;
		i2c-mux,deselect-on-exit;
		#address-cells = <1>;
		#size-cells = <0>;

		max9296_3: cti_max9296@48 {
			#address-cells = <1>;
			#size-cells = <0>;
			compatible = "cti,max929x";
			reg = <0x48>;
			status = SERDES_STATE;
			cti,csi-freq-mhz = <1500>;
			cti,lane-mode = <1>;
			cti,always-on; 
			i2c@0 {
				#address-cells = <1>;
				#size-cells = <0>;
				reg = <0>;
				i2c-mux,deselect-on-exit;
				force_bus_start = <53>;
			        avt_csi2_g@32 {
				    AVT_NODE_COMMON
				    devnode = "video6";
				    reg = <0x32>;
				    csi_clk_freq = <650000000>;
				    csi_lanes = "4";

				    mode0 {
					num_lanes = "4";
					vc_id = "0";
					tegra_sinterface = "serial_a";
					AVT_MODE_0
				    };

				    ports{
					#address-cells = <1>;
					#size-cells = <0>;
					port@0 {
					    reg = <0>;
					    avt_csi2_cam_out6: endpoint {
						port-index = <0>;
						bus-width = <4>;
						vc-id = <0>;
						remote-endpoint = <&avt_csi2_csi_in6>;
					    };
					};
				    };
				};
				avt_csi2_h@33 {
					AVT_NODE_COMMON
					devnode = "video7";
					reg = <0x33>;
					csi_clk_freq = <650000000>;
					csi_lanes = "4";
					mode0 {
					    num_lanes = "4";
					    vc_id = "1";
					    tegra_sinterface = "serial_a";
					    AVT_MODE_0
					};

					ports{
					    #address-cells = <1>;
					    #size-cells = <0>;
					    port@0 {
						reg = <0>;
						avt_csi2_cam_out7: endpoint {
						    port-index = <0>;
						    bus-width = <4>;
						    vc-id = <1>;
						    remote-endpoint = <&avt_csi2_csi_in7>;
						};
					    };
					};
				 };   
                    
			};
			cti_max96717_A {
				reg = <0x40>;
				cti,def-addr = <0x40>;
				cti,lane-mode = <1>; //was 5
				cti,vc-id = <0>;
				cti,i2c-map = <0x32 0x3c>;
				cti,tx-pipe = <2>;
				cti,pipes-dt = <0x0 0x0 0x24 0x0>;

				ports {
					#address-cells = <1>;
					#size-cells = <0>;
					port@0 {
						reg = <0>;
						cti_max9295_a3_in: endpoint {
							//remote-endpoint = <&cam_out0>;
						};
					};
					port@1 {
						reg = <1>;
						cti_max9295_a3_out: endpoint {
							//remote-endpoint = <&avt_csi2_csi_in0>;
						};
					};
				};
			};
			cti_max96717_B {
				reg = <0x62>; //force to 62
				cti,def-addr = <0x40>;
				cti,lane-mode = <1>;
				cti,vc-id = <1>;
				cti,i2c-map = <0x33 0x3c>;
				cti,pipes-dt = <0x24 0 0 0>;
				cti,tx-pipe = <0>;
				ports {
				    #address-cells = <1>;
				    #size-cells = <0>;
				    port@0 {
					reg = <0>;
					cti_max9295_b3_in: endpoint {
					    //remote-endpoint = <&cam_out1>;
					};
				    };
				    port@1 {
					reg = <1>;
					cti_max9295_b3_out: endpoint {
					    //remote-endpoint = <&avt_csi2_csi_in1>;
					};
				    };
				};
			    };


		};
			
            };
        };
    };

    i2c@3180000 {
		status = "okay";
		#address-cells = <1>;
		#size-cells = <0>;
		tca9539_74: tca9539@74 {
			compatible = "ti,tca9539";
			gpio-controller;
			#gpio-cells = <2>;
			ngpios = <16>;
			reg = <0x74>;
			vcc-supply = <&battery_reg>;
			status = "okay";
			
			tca9539_74_outlow {
				status = "okay";
				gpio-hog;
				gpios = <0 0 1 0 2 0 3 0 4 0 5 0 6 0 7 0 8 0 9 0 10 0 11 0 12 0 13 0>;
				output-low;
				label = "RST_A","PWDN_A","RST_B","PWDN_B","RST_C","PWDN_C","RST_D","PWDN_D";
			};
			tca9539_74_outhigh {
				status = "disabled";
			};
			tca9539_74_input {
				status = "disabled";
			};
		};
	};

    tegra-capture-vi {
            num-channels = <8>;
            status="okay";
            ports {
                #address-cells = <1>;
                #size-cells = <0>;
                port@0 {
                    reg = <0>;
                    status="okay";
                    avt_csi2_vi_in0: endpoint {
                        status="okay";
                        port-index = <5>;
                        bus-width = <4>;
            		vc-id = <0>;
                        remote-endpoint = <&avt_csi2_csi_out0>;
                    };
                };
                port@1 {
                    reg = <1>;
                    status="okay";
                    avt_csi2_vi_in1: endpoint {
                        status="okay";
                        port-index = <5>;
                        bus-width = <4>;
            		vc-id = <1>;
                        remote-endpoint = <&avt_csi2_csi_out1>;
                    };
                };
		port@2 {
                    reg = <2>;
                    status="okay";
                    avt_csi2_vi_in2: endpoint {
                        status="okay";
                        port-index = <4>;
                        bus-width = <4>;
            		vc-id = <0>;
                        remote-endpoint = <&avt_csi2_csi_out2>;
                    };
                };
                port@3 {
                    reg = <3>;
                    status="okay";
                    avt_csi2_vi_in3: endpoint {
                        status="okay";
                        port-index = <4>;
                        bus-width = <4>;
            		vc-id = <1>;
                        remote-endpoint = <&avt_csi2_csi_out3>;
                    };
                };
		port@4 {
                    reg = <4>;
                    status="okay";
                    avt_csi2_vi_in4: endpoint {
                        status="okay";
                        port-index = <2>;
                        bus-width = <4>;
            		vc-id = <0>;
                        remote-endpoint = <&avt_csi2_csi_out4>;
                    };
                };
                port@5 {
                    reg = <5>;
                    status="okay";
                    avt_csi2_vi_in5: endpoint {
                        status="okay";
                        port-index = <2>;
                        bus-width = <4>;
            		vc-id = <1>;
                        remote-endpoint = <&avt_csi2_csi_out5>;
                    };
                };
		port@6 {
                    reg = <6>;
                    status="okay";
                    avt_csi2_vi_in6: endpoint {
                        status="okay";
                        port-index = <0>;
                        bus-width = <4>;
            		vc-id = <0>;
                        remote-endpoint = <&avt_csi2_csi_out6>;
                    };
                };
                port@7 {
                    reg = <7>;
                    status="okay";
                    avt_csi2_vi_in7: endpoint {
                        status="okay";
                        port-index = <0>;
                        bus-width = <4>;
            		vc-id = <1>;
                        remote-endpoint = <&avt_csi2_csi_out7>;
                    };
                };

            };
};

        host1x@13e00000 {
          status = "okay";
         nvcsi@15a00000 {
            num-channels = <8>;
            #address-cells = <1>;
            #size-cells = <0>;
            status="okay";

            channel@0 {
                status="okay";
                reg = <0>;
                ports {
                    status="okay";
                    #address-cells = <1>;
                    #size-cells = <0>;
                    port@0 {
                        reg = <0>;
                        status="okay";
                        avt_csi2_csi_in0: endpoint@0 {
                            status="okay";
                            port-index = <6>;
                            bus-width = <4>;
                            remote-endpoint = <&avt_csi2_cam_out0>;
                        };
                    };
                    port@1 {
                        status="okay";
                        reg = <1>;
                        avt_csi2_csi_out0: endpoint@1 {
                            status="okay";
                            remote-endpoint = <&avt_csi2_vi_in0>;
                        };
                    };
                };
            };
            channel@1 {
                status="okay";
                reg = <1>;
                ports {
                    status="okay";
                    #address-cells = <1>;
                    #size-cells = <0>;
                    port@0 {
                        reg = <0>;
                        status="okay";
                        avt_csi2_csi_in1: endpoint@2 {
                            status="okay";
                            port-index = <6>;
                            bus-width = <4>;
                            remote-endpoint = <&avt_csi2_cam_out1>;
                        };
                    };
                    port@1 {
                        status="okay";
                        reg = <1>;
                        avt_csi2_csi_out1: endpoint@3 {
                            status="okay";
                            remote-endpoint = <&avt_csi2_vi_in1>;
                        };
                    };
                };
            };
	    channel@2 {
                status="okay";
                reg = <2>;
                ports {
                    status="okay";
                    #address-cells = <1>;
                    #size-cells = <0>;
                    port@0 {
                        reg = <0>;
                        status="okay";
                        avt_csi2_csi_in2: endpoint@4 {
                            status="okay";
                            port-index = <4>;
                            bus-width = <4>;
                            remote-endpoint = <&avt_csi2_cam_out2>;
                        };
                    };
                    port@1 {
                        status="okay";
                        reg = <1>;
                        avt_csi2_csi_out2: endpoint@5 {
                            status="okay";
                            remote-endpoint = <&avt_csi2_vi_in2>;
                        };
                    };
                };
            };
            channel@3 {
                status="okay";
                reg = <3>;
                ports {
                    status="okay";
                    #address-cells = <1>;
                    #size-cells = <0>;
                    port@0 {
                        reg = <0>;
                        status="okay";
                        avt_csi2_csi_in3: endpoint@6 {
                            status="okay";
                            port-index = <4>;
                            bus-width = <4>;
                            remote-endpoint = <&avt_csi2_cam_out3>;
                        };
                    };
                    port@1 {
                        status="okay";
                        reg = <1>;
                        avt_csi2_csi_out3: endpoint@7 {
                            status="okay";
                            remote-endpoint = <&avt_csi2_vi_in3>;
                        };
                    };
                };
            };
	    channel@4 {
                status="okay";
                reg = <4>;
                ports {
                    status="okay";
                    #address-cells = <1>;
                    #size-cells = <0>;
                    port@0 {
                        reg = <0>;
                        status="okay";
                        avt_csi2_csi_in4: endpoint@8 {
                            status="okay";
                            port-index = <2>;
                            bus-width = <4>;
                            remote-endpoint = <&avt_csi2_cam_out4>;
                        };
                    };
                    port@1 {
                        status="okay";
                        reg = <1>;
                        avt_csi2_csi_out4: endpoint@9 {
                            status="okay";
                            remote-endpoint = <&avt_csi2_vi_in4>;
                        };
                    };
                };
            };
            channel@5 {
                status="okay";
                reg = <5>;
                ports {
                    status="okay";
                    #address-cells = <1>;
                    #size-cells = <0>;
                    port@0 {
                        reg = <0>;
                        status="okay";
                        avt_csi2_csi_in5: endpoint@10 {
                            status="okay";
                            port-index = <2>;
                            bus-width = <4>;
                            remote-endpoint = <&avt_csi2_cam_out5>;
                        };
                    };
                    port@1 {
                        status="okay";
                        reg = <1>;
                        avt_csi2_csi_out5: endpoint@11 {
                            status="okay";
                            remote-endpoint = <&avt_csi2_vi_in5>;
                        };
                    };
                };
            };
	    channel@6 {
                status="okay";
                reg = <6>;
                ports {
                    status="okay";
                    #address-cells = <1>;
                    #size-cells = <0>;
                    port@0 {
                        reg = <0>;
                        status="okay";
                        avt_csi2_csi_in6: endpoint@12 {
                            status="okay";
                            port-index = <0>;
                            bus-width = <4>;
                            remote-endpoint = <&avt_csi2_cam_out6>;
                        };
                    };
                    port@1 {
                        status="okay";
                        reg = <1>;
                        avt_csi2_csi_out6: endpoint@13 {
                            status="okay";
                            remote-endpoint = <&avt_csi2_vi_in6>;
                        };
                    };
                };
            };
            channel@7 {
                status="okay";
                reg = <7>;
                ports {
                    status="okay";
                    #address-cells = <1>;
                    #size-cells = <0>;
                    port@0 {
                        reg = <0>;
                        status="okay";
                        avt_csi2_csi_in7: endpoint@14 {
                            status="okay";
                            port-index = <0>;
                            bus-width = <4>;
                            remote-endpoint = <&avt_csi2_cam_out7>;
                        };
                    };
                    port@1 {
                        status="okay";
                        reg = <1>;
                        avt_csi2_csi_out7: endpoint@15 {
                            status="okay";
                            remote-endpoint = <&avt_csi2_vi_in7>;
                        };
                    };
                };
            };







        };
    };

                        
    tegra-camera-platform {
        num_csi_lanes = <16>;
        max_lane_speed = <4000000>;
        min_bits_per_pixel = <8>;
        vi_peak_byte_per_pixel = <1>;
        vi_bw_margin_pct = <25>;
	max_pixel_rate = <240000>;
        isp_peak_byte_per_pixel = <5>;
        isp_bw_margin_pct = <25>;
	compatible = "nvidia, tegra-camera-platform";
	status = "okay";
        
	modules {
		status = "okay";
		module0 {
			status = "okay";
            		pcl_id = "v4l2_sensor";
            		devname = "avt_csi2 0 40-0032";
            		orientation = "1";
			drivernode0 {
				status = "okay";
				pcl_id = "v4l2_sensor";
				devname = "avt_csi2 0 40-0032";
				proc-device-tree = "/proc/device-tree/i2c@31e0000/tca9544@72/i2c@0/cti_max9296@48/i2c@0/avt_csi2_a@32";
			};
			
		};
		module1 {
			status = "okay";
			badge = "avt_csi2_center";
			position = "center";
			orientation = "1";
			drivernode0 {
				status = "okay";
				pcl_id = "v4l2_sensor";
				devname = "avt_csi2 1 40-0033";
				proc-device-tree = "/proc/device-tree/i2c@31e0000/tca9544@72/i2c@0/cti_max9296/i2c@0/avt_csi2_b@33";
		    };
		};
		module2 {
			status = "okay";
            		pcl_id = "v4l2_sensor";
            		devname = "avt_csi2 0 41-0032";
            		orientation = "1";
			drivernode0 {
				status = "okay";
				pcl_id = "v4l2_sensor";
				devname = "avt_csi2 0 41-0032";
				proc-device-tree = "/proc/device-tree/i2c@31e0000/tca9544@72/i2c@1/cti_max9296@48/i2c@0/avt_csi2_c@32";
			};
			
		};
		module3 {
			status = "okay";
			badge = "avt_csi2_center";
			position = "center";
			orientation = "1";
			drivernode0 {
				status = "okay";
				pcl_id = "v4l2_sensor";
				devname = "avt_csi2 1 41-0033";
				proc-device-tree = "/proc/device-tree/i2c@31e0000/tca9544@72/i2c@1/cti_max9296/i2c@0/avt_csi2_d@33";
		    };
		};
		module4 {
			status = "okay";
            		pcl_id = "v4l2_sensor";
            		devname = "avt_csi2 0 42-0032";
            		orientation = "1";
			drivernode0 {
				status = "okay";
				pcl_id = "v4l2_sensor";
				devname = "avt_csi2 0 42-0032";
				proc-device-tree = "/proc/device-tree/i2c@31e0000/tca9544@72/i2c@2/cti_max9296@48/i2c@0/avt_csi2_e@32";
			};
			
		};
		module5 {
			status = "okay";
			badge = "avt_csi2_center";
			position = "center";
			orientation = "1";
			drivernode0 {
				status = "okay";
				pcl_id = "v4l2_sensor";
				devname = "avt_csi2 1 42-0033";
				proc-device-tree = "/proc/device-tree/i2c@31e0000/tca9544@72/i2c@2/cti_max9296/i2c@0/avt_csi2_f@33";
		    };
		};
		module6 {
			status = "okay";
            		pcl_id = "v4l2_sensor";
            		devname = "avt_csi2 0 43-0032";
            		orientation = "1";
			drivernode0 {
				status = "okay";
				pcl_id = "v4l2_sensor";
				devname = "avt_csi2 0 43-0032";
				proc-device-tree = "/proc/device-tree/i2c@31e0000/tca9544@72/i2c@3/cti_max9296@48/i2c@0/avt_csi2_g@32";
			};
			
		};
		module7 {
			status = "okay";
			badge = "avt_csi2_center";
			position = "center";
			orientation = "1";
			drivernode0 {
				status = "okay";
				pcl_id = "v4l2_sensor";
				devname = "avt_csi2 1 43-0033";
				proc-device-tree = "/proc/device-tree/i2c@31e0000/tca9544@72/i2c@3/cti_max9296/i2c@0/avt_csi2_h@33";
		    };
		};
		
        };
    };
};
